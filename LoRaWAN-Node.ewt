<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <configuration>
    <name>ping-pong</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>LoRaMac</name>
      <group>
        <name>classA</name>
        <file>
          <name>$PROJ_DIR$\apps\LoRaMac\classA\Bleeper-76\main.c</name>
        </file>
      </group>
      <group>
        <name>classB</name>
        <file>
          <name>$PROJ_DIR$\apps\LoRaMac\classB\Bleeper-76\main.c</name>
        </file>
      </group>
      <group>
        <name>classC</name>
        <file>
          <name>$PROJ_DIR$\apps\LoRaMac\classC\Bleeper-76\main.c</name>
        </file>
      </group>
      <group>
        <name>radioCoverageTest</name>
        <file>
          <name>$PROJ_DIR$\apps\LoRaMac\radioCoverageTest\Bleeper-76\main.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>ping-pong</name>
      <file>
        <name>$PROJ_DIR$\apps\ping-pong\Bleeper-76\main.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>hal</name>
    <file>
      <name>$PROJ_DIR$\hal\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\crypto\aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\crypto\aes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\crypto\cmac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\crypto\cmac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\eeprom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\fifo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\fifo.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\gps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\gps.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\LoRaMac-board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\pinName-board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\pinName-ioe.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\selector.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\selector.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\serial.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\spi-board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\spi-board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\sx1276-board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\sx1276-board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\utilities.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal\utilities.h</name>
    </file>
  </group>
  <group>
    <name>mac</name>
    <file>
      <name>$PROJ_DIR$\mac\LoRaMac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\mac\LoRaMac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\mac\LoRaMacCrypto.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\mac\LoRaMacCrypto.h</name>
    </file>
  </group>
  <group>
    <name>radio</name>
    <file>
      <name>$PROJ_DIR$\radio\radio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\radio\sx1276.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\radio\sx1276.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\radio\sx1276Regs-Fsk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\radio\sx1276Regs-LoRa.h</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_aes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_beep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_comp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_irtim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_itc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_rst.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_wfe.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_comp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_irtim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\stm8l15x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_wfe.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
      </file>
    </group>
  </group>
</project>


