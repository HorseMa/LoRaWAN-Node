# IAR project LoRaWAN-Node.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x80
  ICCSTM8.CCDefines: STM8L15X_MD; USE_BAND_433
  ICCSTM8.CCIncludePath2: ; apps; hal; hal\crypto; mac; radio; STM8L15x_StdPeriph_Driver; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LoRaWAN-Node.srec
  ILINK.IlinkOutputFile: LoRaWAN-Node.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
configuration ping-pong (STM8, debug)
  as the first configuration, except:
  group app/LoRaMac/classA
    apps/LoRaMac/classA/Bleeper-76/: main.c
  group app/LoRaMac/classB
    apps/LoRaMac/classB/Bleeper-76/: main.c
  group app/LoRaMac/classC
    apps/LoRaMac/classC/Bleeper-76/: main.c
  group app/LoRaMac/radioCoverageTest
    apps/LoRaMac/radioCoverageTest/Bleeper-76/: main.c
  group app/ping-pong
    apps/ping-pong/Bleeper-76/: main.c
  group hal
    hal/: adc.c adc.h board.c board.h delay.c delay.h eeprom.c eeprom.h fifo.c fifo.h gpio.c gpio.h gps.c gps.h i2c.c i2c.h LoRaMac-board.h pinName-board.h pinName-ioe.h selector.c selector.h serial.h spi-board.c spi-board.h spi.h sx1276-board.c sx1276-board.h timer.c timer.h uart.c uart.h utilities.c utilities.h
    hal/crypto/: aes.c aes.h cmac.c cmac.h
  group mac
    mac/: LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h
  group radio
    radio/: radio.h sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group STM8L15x_StdPeriph_Driver/inc
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group STM8L15x_StdPeriph_Driver/src
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
    STM8L15x_StdPeriph_Driver/: stm8l15x_it.c
